# Keil uVision project freertos.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos_yuntai +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=5
  c define: STM32F10X_ MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\MiniBalance_COER;..\STM32F10x_FWLib\inc;..\MiniBalance_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MiniBalance_HARDWARE\LED;..\MiniBalance_HARDWARE\KEY;..\MiniBalance_HARDWARE\MOTOR;..\MiniBalance\CONTROL;..\FreeRTOS-Kernel\include;..\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;..\MiniBalance_HARDWARE\motor_model;..\MiniBalance_HARDWARE\SR04
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group CORE
    ../MiniBalance_COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../MiniBalance_HARDWARE/LED/: LED.C
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/MOTOR/: motor.c
    ../MiniBalance_HARDWARE/motor_model/: app_motor_usart.c bsp_motor_usart.c
    ../MiniBalance_HARDWARE/SR04/: SR04.c
    ../MiniBalance_HARDWARE/exercise/: exercise.c
  group MiniBalance
    ../MiniBalance/CONTROL/: control.c
  group freertos_core
    ../freertos_core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_portable
    ../freertos_port/: heap_4.c port.c
